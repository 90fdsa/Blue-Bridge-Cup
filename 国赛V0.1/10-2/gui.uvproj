# Keil uVision project gui.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: gui +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 gui.c init.c init.h display.c display.h key.c key.h onewire.c onewire.h ultrasonic.c ultrasonic.h iic.c iic.h led.c led.h series.c series.h
