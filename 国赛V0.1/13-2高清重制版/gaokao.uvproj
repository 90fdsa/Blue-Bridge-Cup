# Keil uVision project gaokao.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: gaokao +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 gaokao.c init.c init.h key.c key.h show.c show.h iic.c iic.h ultrasonic.c ultrasonic.h jidianqi.c jidianqi.h led.c led.h
