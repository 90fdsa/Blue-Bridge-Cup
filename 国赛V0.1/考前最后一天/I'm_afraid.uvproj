# Keil uVision project I'm_afraid.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: I'm_afraid +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 shift.c init.c init.h key.c key.h show.c show.h ds1302.c iic.c onewire.c ds1302.h onewire.h iic.h ultrasonic.c ultrasonic.h uart.c uart.h led.c led.h
