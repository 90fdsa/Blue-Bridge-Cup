# Keil uVision project bailu.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: bailu +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 woqu.c init.c init.h show.c show.h BTN.c BTN.h iic.c iic.h ultrasonic.c ultrasonic.h jidianqi.c jidianqi.h led.c led.h
