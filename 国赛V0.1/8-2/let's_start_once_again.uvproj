# Keil uVision project let's_start_once_again.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: let's_start_once_again +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 lai.c show.c show.h key.c key.h init.c init.h ultrasonic.c ultrasonic.h iic.h iic.c led.c led.h
