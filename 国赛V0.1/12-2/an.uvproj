# Keil uVision project an.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: an +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 saf.c init.c init.h show.c show.h button.c button.h ds1302.c ds1302.h ultrasonic.c ultrasonic.h iic.c iic.h led.c led.h
